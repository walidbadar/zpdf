/*
 * Copyright (c) 2026 Muhammad Waleed Badar
 * SPDX-License-Identifier: GPL-3.0-only
 *
 * Predefined simple-font encodings (Annex D) and a compact glyph list.
 */
#include "pdf_encodings.h"
#include <string.h>

/* 0x80..0xFF of WinAnsiEncoding (cp1252) */
static const uint16_t winansi_high[128] = {
	0x20AC, 0, 0x201A, 0x0192, 0x201E, 0x2026, 0x2020, 0x2021, 0x02C6, 0x2030, 0x0160, 0x2039,
	0x0152, 0, 0x017D, 0, 0, 0x2018, 0x2019, 0x201C, 0x201D, 0x2022, 0x2013, 0x2014, 0x02DC,
	0x2122, 0x0161, 0x203A, 0x0153, 0, 0x017E, 0x0178, 0x00A0, 0x00A1, 0x00A2, 0x00A3, 0x00A4,
	0x00A5, 0x00A6, 0x00A7, 0x00A8, 0x00A9, 0x00AA, 0x00AB, 0x00AC, 0x00AD, 0x00AE, 0x00AF,
	0x00B0, 0x00B1, 0x00B2, 0x00B3, 0x00B4, 0x00B5, 0x00B6, 0x00B7, 0x00B8, 0x00B9, 0x00BA,
	0x00BB, 0x00BC, 0x00BD, 0x00BE, 0x00BF, 0x00C0, 0x00C1, 0x00C2, 0x00C3, 0x00C4, 0x00C5,
	0x00C6, 0x00C7, 0x00C8, 0x00C9, 0x00CA, 0x00CB, 0x00CC, 0x00CD, 0x00CE, 0x00CF, 0x00D0,
	0x00D1, 0x00D2, 0x00D3, 0x00D4, 0x00D5, 0x00D6, 0x00D7, 0x00D8, 0x00D9, 0x00DA, 0x00DB,
	0x00DC, 0x00DD, 0x00DE, 0x00DF, 0x00E0, 0x00E1, 0x00E2, 0x00E3, 0x00E4, 0x00E5, 0x00E6,
	0x00E7, 0x00E8, 0x00E9, 0x00EA, 0x00EB, 0x00EC, 0x00ED, 0x00EE, 0x00EF, 0x00F0, 0x00F1,
	0x00F2, 0x00F3, 0x00F4, 0x00F5, 0x00F6, 0x00F7, 0x00F8, 0x00F9, 0x00FA, 0x00FB, 0x00FC,
	0x00FD, 0x00FE, 0x00FF};

/* 0x80..0xFF of MacRomanEncoding */
static const uint16_t macroman_high[128] = {
	0x00C4, 0x00C5, 0x00C7, 0x00C9, 0x00D1, 0x00D6, 0x00DC, 0x00E1, 0x00E0, 0x00E2, 0x00E4,
	0x00E3, 0x00E5, 0x00E7, 0x00E9, 0x00E8, 0x00EA, 0x00EB, 0x00ED, 0x00EC, 0x00EE, 0x00EF,
	0x00F1, 0x00F3, 0x00F2, 0x00F4, 0x00F6, 0x00F5, 0x00FA, 0x00F9, 0x00FB, 0x00FC, 0x2020,
	0x00B0, 0x00A2, 0x00A3, 0x00A7, 0x2022, 0x00B6, 0x00DF, 0x00AE, 0x00A9, 0x2122, 0x00B4,
	0x00A8, 0x2260, 0x00C6, 0x00D8, 0x221E, 0x00B1, 0x2264, 0x2265, 0x00A5, 0x00B5, 0x2202,
	0x2211, 0x220F, 0x03C0, 0x222B, 0x00AA, 0x00BA, 0x03A9, 0x00E6, 0x00F8, 0x00BF, 0x00A1,
	0x00AC, 0x221A, 0x0192, 0x2248, 0x2206, 0x00AB, 0x00BB, 0x2026, 0x00A0, 0x00C0, 0x00C3,
	0x00D5, 0x0152, 0x0153, 0x2013, 0x2014, 0x201C, 0x201D, 0x2018, 0x2019, 0x00F7, 0x25CA,
	0x00FF, 0x0178, 0x2044, 0x20AC, 0x2039, 0x203A, 0xFB01, 0xFB02, 0x2021, 0x00B7, 0x201A,
	0x201E, 0x2030, 0x00C2, 0x00CA, 0x00C1, 0x00CB, 0x00C8, 0x00CD, 0x00CE, 0x00CF, 0x00CC,
	0x00D3, 0x00D4, 0xF8FF, 0x00D2, 0x00DA, 0x00DB, 0x00D9, 0x0131, 0x02C6, 0x02DC, 0x00AF,
	0x02D8, 0x02D9, 0x02DA, 0x00B8, 0x02DD, 0x02DB, 0x02C7};

/* StandardEncoding high half entries that differ from nothing (sparse). */
static const struct {
	uint8_t code;
	uint16_t uni;
} standard_high[] = {
	{0xA1, 0x00A1}, {0xA2, 0x00A2}, {0xA3, 0x00A3}, {0xA4, 0x2044}, {0xA5, 0x00A5},
	{0xA6, 0x0192}, {0xA7, 0x00A7}, {0xA8, 0x00A4}, {0xA9, 0x0027}, {0xAA, 0x201C},
	{0xAB, 0x00AB}, {0xAC, 0x2039}, {0xAD, 0x203A}, {0xAE, 0xFB01}, {0xAF, 0xFB02},
	{0xB1, 0x2013}, {0xB2, 0x2020}, {0xB3, 0x2021}, {0xB4, 0x00B7}, {0xB6, 0x00B6},
	{0xB7, 0x2022}, {0xB8, 0x201A}, {0xB9, 0x201E}, {0xBA, 0x201D}, {0xBB, 0x00BB},
	{0xBC, 0x2026}, {0xBD, 0x2030}, {0xBF, 0x00BF}, {0xC1, 0x0060}, {0xC2, 0x00B4},
	{0xC3, 0x02C6}, {0xC4, 0x02DC}, {0xC5, 0x00AF}, {0xC6, 0x02D8}, {0xC7, 0x02D9},
	{0xC8, 0x00A8}, {0xCA, 0x02DA}, {0xCB, 0x00B8}, {0xCD, 0x02DD}, {0xCE, 0x02DB},
	{0xCF, 0x02C7}, {0xD0, 0x2014}, {0xE1, 0x00C6}, {0xE3, 0x00AA}, {0xE8, 0x0141},
	{0xE9, 0x00D8}, {0xEA, 0x0152}, {0xEB, 0x00BA}, {0xF1, 0x00E6}, {0xF5, 0x0131},
	{0xF8, 0x0142}, {0xF9, 0x00F8}, {0xFA, 0x0153}, {0xFB, 0x00DF},
};

void pdf_encoding_fill(enum pdf_base_encoding enc, uint16_t *table)
{
	for (int c = 0; c < 256; c++) {
		table[c] = 0;
	}
	for (int c = 0x20; c < 0x7F; c++) {
		table[c] = (uint16_t)c;
	}
	switch (enc) {
	case PDF_ENC_WINANSI:
		for (int c = 0x80; c < 0x100; c++) {
			table[c] = winansi_high[c - 0x80];
		}
		table[0xA0] = 0x00A0;
		table[0xAD] = 0x002D;
		break;
	case PDF_ENC_MACROMAN:
		for (int c = 0x80; c < 0x100; c++) {
			table[c] = macroman_high[c - 0x80];
		}
		break;
	case PDF_ENC_STANDARD:
		table[0x27] = 0x2019;
		table[0x60] = 0x2018;
		for (size_t i = 0; i < sizeof(standard_high) / sizeof(standard_high[0]); i++) {
			table[standard_high[i].code] = standard_high[i].uni;
		}
		break;
	}
}

/* Glyph names -> Unicode. Letters and digits are handled in code. */
static const struct {
	const char *name;
	uint16_t uni;
} glyph_list[] = {
	{"space", 0x20}, {"exclam", 0x21}, {"quotedbl", 0x22}, {"numbersign", 0x23},
	{"dollar", 0x24}, {"percent", 0x25}, {"ampersand", 0x26}, {"quotesingle", 0x27},
	{"parenleft", 0x28}, {"parenright", 0x29}, {"asterisk", 0x2A}, {"plus", 0x2B},
	{"comma", 0x2C}, {"hyphen", 0x2D}, {"period", 0x2E}, {"slash", 0x2F},
	{"colon", 0x3A}, {"semicolon", 0x3B}, {"less", 0x3C}, {"equal", 0x3D},
	{"greater", 0x3E}, {"question", 0x3F}, {"at", 0x40}, {"bracketleft", 0x5B},
	{"backslash", 0x5C}, {"bracketright", 0x5D}, {"asciicircum", 0x5E}, {"underscore", 0x5F},
	{"grave", 0x60}, {"braceleft", 0x7B}, {"bar", 0x7C}, {"braceright", 0x7D},
	{"asciitilde", 0x7E}, {"quoteright", 0x2019}, {"quoteleft", 0x2018},
	{"quotedblleft", 0x201C}, {"quotedblright", 0x201D}, {"quotesinglbase", 0x201A},
	{"quotedblbase", 0x201E}, {"endash", 0x2013}, {"emdash", 0x2014}, {"bullet", 0x2022},
	{"ellipsis", 0x2026}, {"dagger", 0x2020}, {"daggerdbl", 0x2021}, {"perthousand", 0x2030},
	{"guilsinglleft", 0x2039}, {"guilsinglright", 0x203A}, {"guillemotleft", 0xAB},
	{"guillemotright", 0xBB}, {"fi", 0xFB01}, {"fl", 0xFB02}, {"ff", 0xFB00},
	{"ffi", 0xFB03}, {"ffl", 0xFB04}, {"trademark", 0x2122}, {"registered", 0xAE},
	{"copyright", 0xA9}, {"degree", 0xB0}, {"plusminus", 0xB1}, {"multiply", 0xD7},
	{"divide", 0xF7}, {"section", 0xA7}, {"paragraph", 0xB6}, {"periodcentered", 0xB7},
	{"middot", 0xB7}, {"cent", 0xA2}, {"sterling", 0xA3}, {"yen", 0xA5}, {"Euro", 0x20AC},
	{"currency", 0xA4}, {"florin", 0x192}, {"exclamdown", 0xA1}, {"questiondown", 0xBF},
	{"ordfeminine", 0xAA}, {"ordmasculine", 0xBA}, {"onesuperior", 0xB9},
	{"twosuperior", 0xB2}, {"threesuperior", 0xB3}, {"onequarter", 0xBC},
	{"onehalf", 0xBD}, {"threequarters", 0xBE}, {"mu", 0xB5}, {"logicalnot", 0xAC},
	{"brokenbar", 0xA6}, {"dieresis", 0xA8}, {"macron", 0xAF}, {"acute", 0xB4},
	{"cedilla", 0xB8}, {"circumflex", 0x2C6}, {"tilde", 0x2DC}, {"caron", 0x2C7},
	{"breve", 0x2D8}, {"dotaccent", 0x2D9}, {"ring", 0x2DA}, {"ogonek", 0x2DB},
	{"hungarumlaut", 0x2DD}, {"minus", 0x2212}, {"fraction", 0x2044}, {"dotlessi", 0x131},
	{"Lslash", 0x141}, {"lslash", 0x142}, {"OE", 0x152}, {"oe", 0x153}, {"AE", 0xC6},
	{"ae", 0xE6}, {"Oslash", 0xD8}, {"oslash", 0xF8}, {"Eth", 0xD0}, {"eth", 0xF0},
	{"Thorn", 0xDE}, {"thorn", 0xFE}, {"germandbls", 0xDF}, {"Scaron", 0x160},
	{"scaron", 0x161}, {"Zcaron", 0x17D}, {"zcaron", 0x17E}, {"Ydieresis", 0x178},
	{"arrowright", 0x2192}, {"arrowleft", 0x2190}, {"arrowup", 0x2191}, {"arrowdown", 0x2193},
	{"lessequal", 0x2264}, {"greaterequal", 0x2265}, {"notequal", 0x2260},
	{"approxequal", 0x2248}, {"infinity", 0x221E}, {"summation", 0x2211},
	{"product", 0x220F}, {"radical", 0x221A}, {"integral", 0x222B}, {"partialdiff", 0x2202},
	{"Delta", 0x2206}, {"Omega", 0x2126}, {"pi", 0x3C0}, {"alpha", 0x3B1}, {"beta", 0x3B2},
	{"gamma", 0x3B3}, {"delta", 0x3B4}, {"theta", 0x3B8}, {"lambda", 0x3BB}, {"sigma", 0x3C3},
	{"omega", 0x3C9}, {"checkmark", 0x2713}, {"nbspace", 0xA0}, {"sfthyphen", 0xAD},
	{"softhyphen", 0xAD}, {"zero", 0x30}, {"one", 0x31}, {"two", 0x32}, {"three", 0x33},
	{"four", 0x34}, {"five", 0x35}, {"six", 0x36}, {"seven", 0x37}, {"eight", 0x38},
	{"nine", 0x39}, {"zero.oldstyle", 0x30}, {"one.oldstyle", 0x31},
	{"two.oldstyle", 0x32}, {"three.oldstyle", 0x33}, {"four.oldstyle", 0x34},
	{"five.oldstyle", 0x35}, {"six.oldstyle", 0x36}, {"seven.oldstyle", 0x37},
	{"eight.oldstyle", 0x38}, {"nine.oldstyle", 0x39},
};

/* Accented Latin letters: base + accent suffix. */
static const struct {
	const char *accent;
	uint16_t combining; /* used to form the code point via a table below */
} accents[] = {
	{"grave", 0}, {"acute", 1}, {"circumflex", 2}, {"tilde", 3}, {"dieresis", 4},
	{"ring", 5}, {"cedilla", 6}, {"caron", 7},
};

/* Precomposed Latin-1 / Latin Extended-A letters for base+accent. */
static uint16_t compose(char base, int accent)
{
	static const struct {
		char b;
		uint16_t v[8]; /* grave acute circumflex tilde dieresis ring cedilla caron */
	} t[] = {
		{'A', {0xC0, 0xC1, 0xC2, 0xC3, 0xC4, 0xC5, 0, 0x1CD}},
		{'a', {0xE0, 0xE1, 0xE2, 0xE3, 0xE4, 0xE5, 0, 0x1CE}},
		{'C', {0, 0x106, 0x108, 0, 0, 0, 0xC7, 0x10C}},
		{'c', {0, 0x107, 0x109, 0, 0, 0, 0xE7, 0x10D}},
		{'E', {0xC8, 0xC9, 0xCA, 0, 0xCB, 0, 0, 0x11A}},
		{'e', {0xE8, 0xE9, 0xEA, 0, 0xEB, 0, 0, 0x11B}},
		{'I', {0xCC, 0xCD, 0xCE, 0x128, 0xCF, 0, 0, 0}},
		{'i', {0xEC, 0xED, 0xEE, 0x129, 0xEF, 0, 0, 0}},
		{'N', {0, 0x143, 0, 0xD1, 0, 0, 0, 0x147}},
		{'n', {0, 0x144, 0, 0xF1, 0, 0, 0, 0x148}},
		{'O', {0xD2, 0xD3, 0xD4, 0xD5, 0xD6, 0, 0, 0}},
		{'o', {0xF2, 0xF3, 0xF4, 0xF5, 0xF6, 0, 0, 0}},
		{'U', {0xD9, 0xDA, 0xDB, 0x168, 0xDC, 0x16E, 0, 0}},
		{'u', {0xF9, 0xFA, 0xFB, 0x169, 0xFC, 0x16F, 0, 0}},
		{'Y', {0, 0xDD, 0x176, 0, 0x178, 0, 0, 0}},
		{'y', {0, 0xFD, 0x177, 0, 0xFF, 0, 0, 0}},
		{'S', {0, 0x15A, 0x15C, 0, 0, 0, 0x15E, 0x160}},
		{'s', {0, 0x15B, 0x15D, 0, 0, 0, 0x15F, 0x161}},
		{'Z', {0, 0x179, 0, 0, 0, 0, 0, 0x17D}},
		{'z', {0, 0x17A, 0, 0, 0, 0, 0, 0x17E}},
		{'G', {0, 0, 0x11C, 0, 0, 0, 0x122, 0}},
		{'g', {0, 0, 0x11D, 0, 0, 0, 0x123, 0}},
		{'R', {0, 0x154, 0, 0, 0, 0, 0, 0x158}},
		{'r', {0, 0x155, 0, 0, 0, 0, 0, 0x159}},
		{'T', {0, 0, 0, 0, 0, 0, 0x162, 0x164}},
		{'t', {0, 0, 0, 0, 0, 0, 0x163, 0x165}},
		{'D', {0, 0, 0, 0, 0, 0, 0, 0x10E}},
		{'d', {0, 0, 0, 0, 0, 0, 0, 0x10F}},
		{'L', {0, 0x139, 0, 0, 0, 0, 0, 0x13D}},
		{'l', {0, 0x13A, 0, 0, 0, 0, 0, 0x13E}},
	};

	for (size_t i = 0; i < sizeof(t) / sizeof(t[0]); i++) {
		if (t[i].b == base) {
			return t[i].v[accent];
		}
	}
	return 0;
}

static int hexv(char c)
{
	if (c >= '0' && c <= '9') {
		return c - '0';
	}
	if (c >= 'a' && c <= 'f') {
		return c - 'a' + 10;
	}
	if (c >= 'A' && c <= 'F') {
		return c - 'A' + 10;
	}
	return -1;
}

uint32_t pdf_glyph_to_unicode(const char *name)
{
	size_t n = strlen(name);

	if (n == 0) {
		return 0;
	}
	if (n == 1) {
		return (uint8_t)name[0];
	}
	/* uniXXXX / uXXXX[XX] */
	if (n >= 7 && memcmp(name, "uni", 3) == 0) {
		uint32_t v = 0;

		for (int i = 3; i < 7; i++) {
			int h = hexv(name[i]);

			if (h < 0) {
				v = 0;
				break;
			}
			v = (v << 4) | (uint32_t)h;
		}
		if (v) {
			return v;
		}
	}
	if (n >= 5 && n <= 7 && name[0] == 'u') {
		uint32_t v = 0;
		bool ok = true;

		for (size_t i = 1; i < n; i++) {
			int h = hexv(name[i]);

			if (h < 0) {
				ok = false;
				break;
			}
			v = (v << 4) | (uint32_t)h;
		}
		if (ok) {
			return v;
		}
	}
	for (size_t i = 0; i < sizeof(glyph_list) / sizeof(glyph_list[0]); i++) {
		if (strcmp(glyph_list[i].name, name) == 0) {
			return glyph_list[i].uni;
		}
	}
	/* "Aacute", "ccedilla", ... */
	for (size_t i = 0; i < sizeof(accents) / sizeof(accents[0]); i++) {
		size_t al = strlen(accents[i].accent);

		if (n == al + 1 && strcmp(name + 1, accents[i].accent) == 0) {
			uint16_t v = compose(name[0], (int)accents[i].combining);

			if (v) {
				return v;
			}
		}
	}
	/* "a.sc", "one.numr": take the part before the dot */
	const char *dot = strchr(name, '.');

	if (dot != NULL && dot != name) {
		char base[32];
		size_t bl = (size_t)(dot - name);

		if (bl < sizeof(base)) {
			memcpy(base, name, bl);
			base[bl] = 0;
			return pdf_glyph_to_unicode(base);
		}
	}
	return 0;
}
